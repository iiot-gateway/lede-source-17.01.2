## target/linux/layerscape/image/Config.in
```kconfig
config ARMV7_SD_BOOT_PARTSIZE
	int "Boot (SD Card) filesystem partition size (in MB)"
	depends on TARGET_layerscape
	default 20
```
